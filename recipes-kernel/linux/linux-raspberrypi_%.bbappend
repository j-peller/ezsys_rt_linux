FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://patch-6.1.77-rt24.patch"
